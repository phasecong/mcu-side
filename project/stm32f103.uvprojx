# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\lib\CMSIS\CM3\CoreSupport;..\dev\inc;..\project;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c
  group dev
    ../dev/src/: dev_delay.c dev_keypad.c dev_utilities.c dev_lcd_i2c.c dev_usart.c
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_usart.c misc.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
